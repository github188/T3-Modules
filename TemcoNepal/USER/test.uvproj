# Keil uVision project test.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\FLASH;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\SDCARD;..\FATFS\src;..\FATFS\exfuns;..\VMALLOC;..\HARDWARE\TIMER;..\HARDWARE\ENC28J60;..\uIP-1.0\uip;..\uIP-1.0\apps\dhcpc;..\uIP-1.0\apps\resolv;..\uIP-1.0\apps\webserver;..\uIP-APP;..\HARDWARE\RTC;..\USB\CONFIG\inc;..\USB\LIB\inc;..\USB\APP;..\MODBUS;..\TCPIP;..\BACNET\handler;..\BACNET\src;..\BACNET\include;..\BACNET;..\BACNET\object;..\KEY;..\FILTER;..\RANGE
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h modbus_regOp.c define.h modbus_response.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CORE/: cortexm3_macro_rvds.s core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/SDCARD/: MMC_SD.C
    ../HARDWARE/RTC/: rtc.c
    ./: inputs.c
    ../OUTPUT/: output.c
    ../KEY/: key.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
  group UIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group UIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp_client_demo.c tcp_demo.c tcp_server_demo.c udp_demo.c udp_scan.h udp_scan.c tcp_demo.h tcp_modbus.h clock-arch.h tapdev.h tcp_modbus.c udp_demo.h uip-conf.h
    ../uIP-1.0/apps/dhcpc/: dhcpc.c
    ../uIP-1.0/apps/resolv/: resolv.c
    ../uIP-1.0/apps/webserver/: http-strings.c httpd.c httpd-cgi.c httpd-fs.c
  group MODBUS
    ../MODBUS/: modbus.c crc.c
  group FILTER
    ../FILTER/: filter.c
  group BACNET
    ../BACNET/src/: bacdcode.c bacreal.c bacint.c mstptext.c bacaddr.c bacprop.c bacpropstates.c datalink.c datetime.c dcc.c indtext.c bacerror.c abort.c rp.c reject.c fifo.c bvlc.c bacapp.c npdu.c iam.c whois.c apdu.c wp.c bacstr.c bacnetcrc.c bip.c ptransfer.c
    ../BACNET/handler/: h_npdu.c txbuf.c s_iam.c s_whois.c h_iam.c noserv.c s_upt.c
    ../BACNET/object/: ao.c bi.c bo.c
    ../BACNET/: dlmstp.c bacnettimer.c av.c bv.c ai.c h_wp.c h_rp.c h_whois.c device.c user_data.c rs485.c ud_str.h user_data.h
    ../bac_lib/: decode.c
  group VMALLOC
    ../VMALLOC/: vmalloc.c
  group bac_lib
    ../bac_lib/: abort.c ai.c ao.c apdu.c av.c bacaddr.c bacapp.c bacdcode.c bacerror.c bacint.c bacnetcrc.c bacnettimer.c bacprop.c bacpropstates.c bacreal.c bacstr.c bi.c bip.c bo.c bv.c bvlc.c datalink.c datetime.c dcc.c decode.c device.c dlmstp.c fifo.c h_iam.c h_npdu.c h_rp.c h_whois.c h_wp.c iam.c indtext.c mstptext.c noserv.c npdu.c POINT.C ptransfer.c reject.c rp.c rs485.c s_iam.c s_upt.c s_whois.c txbuf.c user_data.c whois.c wp.c
  group RANGE
    ../RANGE/: RANGE.C RANGE.H
  group T3P12
    ./: t3-pt12.c read_pt.c pt12_i2c.c
